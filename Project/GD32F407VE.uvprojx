# Keil uVision project GD32F407VE.uvprojx, settings and files
target GD32F4XX (6240000::V6.24::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c include: ..\Application;..\Application\Modules;..\MAL\MCU\Firmware;..\MAL\MCU\Firmware\CMSIS;..\MAL\MCU\Firmware\CMSIS\GD\GD32F4xx\Include;..\MAL\MCU\Firmware\CMSIS\GD\GD32F4xx\Source\ARM;..\MAL\MCU\Firmware\GD32F4xx_standard_peripheral\Include;..\MAL\MCU\CoreModules\JKIC;..\MAL\MCU\ExtModules\GPIO;..\MAL\MCU\ExtModules\TIMER;..\MAL\MCU\ExtModules\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Application/: main.c
    ../Application/Modules/: app_usart.c app_timer_base.c app_led1.c
  group MCU
    ../MAL/MCU/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
    ../MAL/MCU/Firmware/: systick.c gd32f4xx_it.c
    ../MAL/MCU/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../MAL/MCU/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_dac.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_pmu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_wwdgt.c
  group MAL
    ../MAL/MCU/CoreModules/JKIC/: jk_ic.c
    ../MAL/MCU/ExtModules/GPIO/: jk_gpio_i.c jk_gpio_o.c jk_gpio_switch.c
    ../MAL/MCU/ExtModules/TIMER/: jk_timer_base.c
    ../MAL/MCU/ExtModules/USART/: jk_usart.c
software components: CMSIS:CORE 6.2.0
